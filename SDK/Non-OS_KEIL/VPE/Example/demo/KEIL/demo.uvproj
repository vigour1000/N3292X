# Keil uVision project demo.uvproj, settings and files
target VPE_LCM_QVGA (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: IRAM(0xF8002000-0xF8009FFF) CLOCK(24000000) CPUTYPE(ARM926EJ-S)
  output: demo
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c define: LCM_320X240
  c include: ..\..\..\Lib;..\..\..\..\SYSLIB\Lib;..\..\..\..\NVTFAT\lib;..\..\..\..\SIC\Lib;..\..\..\..\VPOST\Lib;..\..\demo;..\..\..\..\GNAND\Lib
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\..\N32926\N32926.sct
  link misc: --entry Reset_Go
  group Source Group 1
    ../../: standalone.c VPE_Aspect.c VPE_Emulation.c VPE_FileAccess.c VPE_FormatConversionRotation_TV.c wb_init.s
    ../../../Lib/: W55FA92_VPE.lib
    ../../../../SYSLIB/Lib/: W55FA92_syslib.lib
    ../../../../NVTFAT/lib/: W55FA92_nvtfat.lib
    ../../../../SIC/Lib/: W55FA92_SIC.lib
    ../../../../VPOST/Lib/: W55FA92_GIANTPLUS_GPM1006D.lib
