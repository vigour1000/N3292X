# Keil uVision project W55FA92_VPOST.uvproj, settings and files
target W55FA92_GIANTPLUS_GPM1006D (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: IRAM(0xF8002000-0xF8009FFF) CLOCK(24000000) CPUTYPE(ARM926EJ-S)
  output: W55FA92_GIANTPLUS_GPM1006D (library)
  AfterMake: W55FA92_GIANTPLUS_GPM1006D.bat
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: __HAVE_GIANTPLUS_GPM1006D0__
  c include: ..\..\Lib;..\..\..\SYSLIB\Lib
  memory RVCT9: RAM 0xf8002000 size 0x8000
  group Source Group 1
    ../: W55FA92_VPOST.C W55FA92_VPOST_AMPIRE_800x480_16B.c W55FA92_VPOST_AMPIRE_800x480_18B.c W55FA92_VPOST_AMPIRE_800x480_24B.c W55FA92_VPOST_Driver.c W55FA92_VPOST_GIANTPLUS_GPM1006D0.c W55FA92_VPOST_HANNSTAR_HSD043I9W1_16B.c W55FA92_VPOST_HANNSTAR_HSD043I9W1_18B.c W55FA92_VPOST_TOPPLY_320x240.c W55FA92_VPOST_TVOUT_D1_720x480.c W55FA92_VPOST_TVOUT_QVGA_320x240.c W55FA92_VPOST_TVOUT_VGA_640x480.c
